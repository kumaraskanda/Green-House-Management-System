# Keil uVision project proj1.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: proj1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s internalRTC.c LCD.c rtc.c uart.c read_from_adc.c blinking_led.c Board_Sys_init.c Control_Sys.c 7seg.c keyboard.c
    C:/Keil_v5/ARM/Boards/Embedded Artists/LPC2148 USB QSB/Blinky/: Retarget.c Serial.c
